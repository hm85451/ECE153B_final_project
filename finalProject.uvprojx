# Keil uVision project finalProject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: finalProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./Source/: main.c startup_stm32l476xx.s stm32l476xx.h DFSDM.c DFSDM.h SPI.c SPI.h SysTimer.c SysTimer.h max7219.c max7219.h SysClock.c SysClock.h EXTI.c EXTI.h fft2.c fft2.h
software components: CMSIS:CORE 5.4.0
